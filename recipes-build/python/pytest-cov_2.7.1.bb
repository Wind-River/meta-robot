
DESCRIPTION = "Colcon Build Tool"
SECTION = "turtlebot3_ws"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cbc4e25353c748c817db2daffe605e43"



PV = "2.7.1"

inherit pypi setuptools3
SRC_URI[md5sum] = "053bc1570960cbc41810cf00997e3995"
PYPI_PACKAGE = "pytest-cov"



BBCLASSEXTEND = "native"
