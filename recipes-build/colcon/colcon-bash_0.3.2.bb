
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=e8b1d7d7b143a598c8229299a9dbb1a7"

PV = "0.3.2"

inherit pypi setuptools3
SRC_URI[md5sum] = "4ca101dad3c32362b00eed63c6c2d6c6"

PYPI_PACKAGE = "colcon-bash"


BBCLASSEXTEND = "native"
