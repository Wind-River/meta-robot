
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=b94a16e5f4e95aa9867f896ab2d41dbd"


PV = "0.2.1"

inherit pypi setuptools3
SRC_URI[md5sum] = "b9a08b6e6246a1db17f2d1b9dccc571b"

PYPI_PACKAGE = "colcon-library-path"



BBCLASSEXTEND = "native"
