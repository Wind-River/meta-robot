
SECTION = "turtlebot3_ws"



PV = "0.3.4"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=42e9ebd2c3361763db6b182d8629f6f1"

inherit pypi setuptools3
SRC_URI[md5sum] = "7ba604decd6bd0eb88b3a07b4562534b"

PYPI_PACKAGE = "colcon-powershell"


BBCLASSEXTEND = "native"
