
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=8edd8c3068954e1b9c2bb3856dc51265"


PV = "0.2.2"

inherit pypi setuptools3
SRC_URI[md5sum] = "7929f632f4829cf6dbf2d993d4b252fd"
PYPI_PACKAGE = "colcon-metadata"


BBCLASSEXTEND = "native"
