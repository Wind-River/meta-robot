
FILES_${PN} += "/usr/setup.zsh \
      /usr/setup.sh \
      /usr/local_setup.bash \
      /usr/local_setup.zsh \
      /usr/local_setup.sh \
      /usr/setup.bash \
      /usr/_order_packages.py \
  "

