
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=2ddcf2fef8029cdc23807cde68dce8ce"



PV = "0.2.1"

inherit pypi setuptools3
SRC_URI[md5sum] = "603c3143ae9a4769c151ce60746611ae"

PYPI_PACKAGE = "colcon-devtools"


BBCLASSEXTEND = "native"
