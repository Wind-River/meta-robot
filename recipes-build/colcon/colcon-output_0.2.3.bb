
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=cb8280f2a74e0c0c1283eaca2c1ff962"



PV = "0.2.3"

inherit pypi setuptools3
SRC_URI[md5sum] = "06946272c292ef34317f7b90f263272c"

PYPI_PACKAGE = "colcon-output"



BBCLASSEXTEND = "native"
