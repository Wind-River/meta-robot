
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=f77dc77081dfcba19fb0cd25e90e7c3e"


PV = "0.2.2"

inherit pypi setuptools3
SRC_URI[md5sum] = "a0b7df616e331a0701975c0ba197e5fe"

PYPI_PACKAGE = "colcon-package-information"


BBCLASSEXTEND = "native"
