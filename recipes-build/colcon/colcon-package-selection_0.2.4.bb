
SECTION = "turtlebot3_ws"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=4e744098c9511fb8c8f3cfa45c5a4c89"


PV = "0.2.4"

inherit pypi setuptools3
SRC_URI[md5sum] = "ee45426fff7dc26a15cbe245910092c7"
PYPI_PACKAGE = "colcon-package-selection"



BBCLASSEXTEND = "native"
