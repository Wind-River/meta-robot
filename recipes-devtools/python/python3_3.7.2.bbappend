do_install_append(){
    rm -f ${D}/${bindir}/2to3
}
