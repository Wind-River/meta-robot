INSANE_SKIP_${PN} += " useless-rpaths "
INSANE_SKIP_${PN} += " dev-so "
